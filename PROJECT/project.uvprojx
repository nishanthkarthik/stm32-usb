# Keil uVision project project.uvprojx, settings and files
target STM32F4-Discovery (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F4XX,KEIL_IDE,TM_DISCO_STM32F4_DISCOVERY,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7
  c include: .\User;.\TM;..\00-STM32F429_LIBRARIES;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\src;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;..\00-STM32F429_LIBRARIES\fatfs;..\00-STM32F429_LIBRARIES\fatfs\option;..\00-STM32F429_LIBRARIES\fatfs\drivers;..\00-STM32F429_LIBRARIES\usb_msc_host
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Startup
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s startup_stm32f401xx.s startup_stm32f411xe.s startup_stm32f429_439xx.s startup_stm32f446xx.s
  group STD_Periph_Drivers
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group TM
    ../00-STM32F429_LIBRARIES/: tm_stm32f4_delay.c tm_stm32f4_delay.h tm_stm32f4_disco.c tm_stm32f4_disco.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h tm_stm32f4_fatfs.c tm_stm32f4_fatfs.h tm_stm32f4_gps.c tm_stm32f4_gps.h tm_stm32f4_usart.c tm_stm32f4_usart.h tm_stm32f4_usb_msc_host.c tm_stm32f4_usb_msc_host.h tm_stm32f4_button.c tm_stm32f4_button.h tm_stm32f4_general.c tm_stm32f4_general.h
  group User
    ./User/: main.h main.c defines.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group Fatfs
    ../00-STM32F429_LIBRARIES/fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../00-STM32F429_LIBRARIES/fatfs/option/: syscall.c unicode.c
    ../00-STM32F429_LIBRARIES/fatfs/drivers/: fatfs_usb.c fatfs_usb.h
  group USB MSC Host
    ../00-STM32F429_LIBRARIES/usb_msc_host/: usb_bsp.c usb_bsp.h usb_conf.h usb_conf_template.h usb_core.c usb_core.h usb_dcd.c usb_dcd.h usb_dcd_int.h usb_defines.h usb_hcd.c usb_hcd.h usb_hcd_int.c usb_hcd_int.h usb_regs.h usbh_conf.h usbh_core.c usbh_core.h usbh_def.h usbh_hcs.c usbh_hcs.h usbh_ioreq.c usbh_ioreq.h usbh_msc_bot.c usbh_msc_bot.h usbh_msc_core.c usbh_msc_core.h usbh_msc_scsi.c usbh_msc_scsi.h usbh_stdreq.c usbh_stdreq.h usbh_usr.c usbh_usr.h
target STM32F429I-Discovery (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,STM32F4XX,KEIL_IDE,TM_DISCO_STM32F429_DISCOVERY,HSE_VALUE=8000000,PLL_M=8,PLL_N=360,PLL_P=2,PLL_Q=7,USE_USB_OTG_HS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
